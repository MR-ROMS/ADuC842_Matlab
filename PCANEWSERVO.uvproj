# Keil uVision project PCANEWSERVO.uvproj, settings and files
target Target_1 (MCS-51)
  device: ADuC842 Analog Devices
  cpu: IRAM(0-0xFF) IROM(0-0xF7FF) XRAM (0-0x7FF) CLOCK(32768) DPX MODAB2
  output: PCANEWSERVO +hex
  c flags: Optimize=8 SizeSpeed=1
  group Source Group 1
    ./: PCANEWSERVO.a51 Robot_Kol_assembly.a51
